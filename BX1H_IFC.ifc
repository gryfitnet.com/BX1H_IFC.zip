Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: Project Number
Time: 2019-06-07T14:57:17
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.0.0.420 - Alternate UI 18.0.0.420
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Fri Jun 07 14:57:17 2019 * Host: DESKTOP-088PFGA * Database: C:\Users\KOMORO~1\AppData\Local\Temp\{FF4F2903-C450-465D-962E-886ED63AFF4A}\ifc * Database version: 5507 * Database creation date: Fri Jun 07 14:57:16 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Fri Jun 07 14:57:16 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Fri Jun 07 14:57:16 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 12, 46, 799999; RefLongitude: -71, -1, -58, -799999; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C + EI230V, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C + EI230V, D=100. DK=124. S=12. P=150:940203
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C + EI230V, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C, D=100. DK=124. S=12. P=150:940187
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=120 + WT72C, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=124. S=12. P=150:940207
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C + EI230V, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C, D=100. DK=124. S=12. P=150:940191
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=150 + WT72C, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C + EI230V, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C + EI230V, D=100. DK=124. S=12. P=150:940195
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C + EI230V, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C, D=100. DK=124. S=12. P=150:940179
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=35 + WT72C, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C + EI230V, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C + EI230V, D=100. DK=124. S=12. P=150:940199
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C + EI230V, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C, D=100. DK=124. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C, D=100. DK=124. S=12. P=150:940183
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=100 + KM, KM=67 + WT72C, D=100. DK=124. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C + EI230V, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C + EI230V, D=125. DK=150. S=12. P=150:940204
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C + EI230V, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C, D=125. DK=150. S=12. P=150:940188
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=120 + WT72C, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=150. S=12. P=150:940208
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C + EI230V, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C, D=125. DK=150. S=12. P=150:940192
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=150 + WT72C, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C + EI230V, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C + EI230V, D=125. DK=150. S=12. P=150:940196
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C + EI230V, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C, D=125. DK=150. S=12. P=150:940180
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=35 + WT72C, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C + EI230V, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C + EI230V, D=125. DK=150. S=12. P=150:940200
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C + EI230V, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C, D=125. DK=150. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C, D=125. DK=150. S=12. P=150:940184
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=125 + KM, KM=67 + WT72C, D=125. DK=150. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C + EI230V, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C + EI230V, D=160. DK=212. S=12. P=150:940205
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C + EI230V, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C, D=160. DK=212. S=12. P=150:940189
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=120 + WT72C, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=12. P=150:940209
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C + EI230V, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=12. P=150:940193
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=150 + WT72C, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C + EI230V, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C + EI230V, D=160. DK=212. S=12. P=150:940197
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C + EI230V, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C, D=160. DK=212. S=12. P=150:940181
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=35 + WT72C, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C + EI230V, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C + EI230V, D=160. DK=212. S=12. P=150:940201
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C + EI230V, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C, D=160. DK=212. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C, D=160. DK=212. S=12. P=150:940185
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=160 + KM, KM=67 + WT72C, D=160. DK=212. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C + EI230V, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C + EI230V, D=200. DK=252. S=12. P=150:940206
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C + EI230V, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C, D=200. DK=252. S=12. P=150:940190
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=120 + WT72C, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=12. P=150:940210
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C + EI230V, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=12. P=150:940194
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=150 + WT72C, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C + EI230V, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C + EI230V, D=200. DK=252. S=12. P=150:940198
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C + EI230V, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C, D=200. DK=252. S=12. P=150:940182
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=35 + WT72C, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C + EI230V, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C + EI230V, D=200. DK=252. S=12. P=150:940202
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C + EI230V, D=200. DK=252. S=12. P=150

# IfcFlowTerminal: GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C, D=200. DK=252. S=12. P=150, GRYFIT BX-1H, Przeciwpożarowy zawór odcinający:GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C, D=200. DK=252. S=12. P=150:940186
In: Level 1
Pset_DistributionFlowElementCommon - Reference: GRYFIT BX-1H, D=200 + KM, KM=67 + WT72C, D=200. DK=252. S=12. P=150
